# Reinstate the fields present in Poky but not in meta-ked-bsp
OS_RELEASE_FIELDS:append = " PRETTY_NAME ID_LIKE VERSION_ID PRETTY_NAME DISTRO_CODENAME"