# TODO NIELS: revise boot partition files
BALENA_BOOT_PARTITION_FILES_kontron-mx8mm = "u-boot.imx:u-boot.imx"
