# TODO NIELS: we might have to add additional
# update scripts here to flash other parts of the
# boot process.
HOSTAPP_HOOKS += "99-resin-uboot"
